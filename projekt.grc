options:
  parameters:
    author: marko
    generate_options: qt_gui
    id: projekt
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sym_durration
  id: variable
  parameters:
    value: '305e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 300e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_4_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_3
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_4
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_4_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_4_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_4_0_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_4_0_0_1
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_repeat_0_5
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*sym_durration)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: blocks_vector_source_x_1_0_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: complex
    vector: (1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"s\") and keyboard.is_pressed(\"d\") == False and keyboard.is_pressed(\"w\") == False and keyboard.is_pressed(\"a\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n\n        \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"a\") and keyboard.is_pressed(\"d\") == False and keyboard.is_pressed(\"s\") == False and keyboard.is_pressed(\"w\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n\n        \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"d\") and keyboard.is_pressed(\"w\") == False and keyboard.is_pressed(\"s\") == False and keyboard.is_pressed(\"a\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"d\") and keyboard.is_pressed(\"w\") and keyboard.is_pressed(\"s\") == False and keyboard.is_pressed(\"a\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_2_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"a\") and keyboard.is_pressed(\"w\") and keyboard.is_pressed(\"s\") == False and keyboard.is_pressed(\"d\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_2_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"a\") and keyboard.is_pressed(\"s\") and keyboard.is_pressed(\"w\") == False and keyboard.is_pressed(\"d\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_2_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport keyboard\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if keyboard.is_pressed(\"d\") and keyboard.is_pressed(\"s\") and keyboard.is_pressed(\"w\") == False and keyboard.is_pressed(\"a\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        else :\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        return len(output_items[0])\n\n        \n     \n     \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom keyboard import is_pressed\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if is_pressed(\"w\") and is_pressed(\"d\") == False and is_pressed(\"s\") == False and is_pressed(\"a\") == False:\n            output_items[0][:] = input_items[0] \n            return len(output_items[0])\n        \n        output_items[0][:] = 0\n            \n        return len(output_items[0])\n\n        \n     \n\n        \n"
    example_param: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 27e6
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: 27e6
    dev_args: hackfr
    samp_rate: samp_rate
    type: fc32
    vga: '100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_4_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_4_0_0, '1']
- [blocks_multiply_xx_0_4_0_0, '0', blocks_throttle2_0, '0']
- [blocks_repeat_0, '0', epy_block_0_3, '0']
- [blocks_repeat_0_3, '0', epy_block_0_0, '0']
- [blocks_repeat_0_4, '0', epy_block_0_2, '0']
- [blocks_repeat_0_4_0, '0', epy_block_0_2_0, '0']
- [blocks_repeat_0_4_0_0, '0', epy_block_0_2_2, '0']
- [blocks_repeat_0_4_0_0_0, '0', epy_block_0_2_1, '0']
- [blocks_repeat_0_4_0_0_1, '0', epy_block_0_2_3, '0']
- [blocks_repeat_0_5, '0', epy_block_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_repeat_0_3, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_0_5, '0']
- [blocks_vector_source_x_1_0, '0', blocks_repeat_0_4, '0']
- [blocks_vector_source_x_1_0_0, '0', blocks_repeat_0_4_0, '0']
- [blocks_vector_source_x_1_0_0_0, '0', blocks_repeat_0_4_0_0, '0']
- [blocks_vector_source_x_1_0_0_0_0, '0', blocks_repeat_0_4_0_0_0, '0']
- [blocks_vector_source_x_1_0_0_0_1, '0', blocks_repeat_0_4_0_0_1, '0']
- [epy_block_0_0, '0', blocks_add_xx_0, '1']
- [epy_block_0_1, '0', blocks_add_xx_0, '2']
- [epy_block_0_2, '0', blocks_add_xx_0, '3']
- [epy_block_0_2_0, '0', blocks_add_xx_0, '4']
- [epy_block_0_2_1, '0', blocks_add_xx_0, '5']
- [epy_block_0_2_2, '0', blocks_add_xx_0, '7']
- [epy_block_0_2_3, '0', blocks_add_xx_0, '6']
- [epy_block_0_3, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
